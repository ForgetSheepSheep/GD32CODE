# Keil uVision project SENSOR.uvprojx, settings and files
target GD32_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Dwt_delay +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Startup;..\Sys;..\User;..\App;..\Driver;..\Library\Source;..\Library\Include;..\Sys\sys_dwt_delay;..\App_Modbus;..\Drv_Modbus;..\Mid_Modbus\functions;..\Mid_Modbus\include;..\Mid_Modbus\rtu;..\Mid_Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Sys
    ../Sys/sys_dwt_delay/: delay.c
    ../Sys/sys_tick/: sys_tick.c
  group User
    ../User/: main.c task.c
  group App
    ../App/app_uart/: app_uart.c
    ../App/app_key/: app_key.c
    ../App/app_sensor/: app_sensor.c
  group Driver
    ../Driver/drv_led/: drv_led.c
    ../Driver/drv_key/: drv_key.c
    ../Driver/drv_uart/: drv_uart.c
    ../Driver/queue/: queue.c
    ../Driver/drv_pwm/: drv_pwm.c
    ../Driver/drv_capture/: drv_capture.c
    ../Driver/drv_rtc/: drv_rtc.c
    ../Driver/drv_dgt/: drv_dgt.c
    ../Driver/drv_adc/: drv_adc.c
    ../Driver/drv_adc_dma/: drv_adc_dma.c
    ../Driver/drv_hum/: drv_hum.c
    ../Driver/drv_temp/: drv_temp.c
    ../Driver/drv_sensor/: drv_sensor.c
  group Library
    ../Library/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group App_Modbus
    ../App_Modbus/: modbus_app.c
  group Drv_Modbus
    ../Drv_Modbus/: portevent.c portserial.c porttimer.c port.c
  group Mid_Modbus
    ../Mid_Modbus/: modbus_slave.c mb.c
    ../Mid_Modbus/rtu/: mbrtu.c mbcrc.c
    ../Mid_Modbus/functions/: mbutils.c mbfuncholding.c
